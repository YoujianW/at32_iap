# Keil uVision project at32_iap_app.uvprojx, settings and files
target at32_iap_app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32_iap_app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../ace_robot_kit/BSP/inc;../../ace_robot_kit/APP/app_config;../../ace_robot_kit/APP/app_task;../../ace_robot_kit/Component/led;../../ace_robot_kit/Component/vofa;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/rvds/ARM_CM4F;
  memory RVCT4: ROM 0x8006000 size 0x5a000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c wk_debug.c wk_usart.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_flash.c at32f403a_407_misc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group ace_robot_kit/BSP
    ../../ace_robot_kit/BSP/src/: bsp_flash.c bsp_usart.c
  group ace_robot_kit/Component
    ../../ace_robot_kit/Component/led/: led.c
    ../../ace_robot_kit/Component/vofa/: vofa.c
  group ace_robot_kit/APP
    ../../ace_robot_kit/APP/app_config/: app_config.c
    ../../ace_robot_kit/APP/app_task/: app_task.c app_debug_task.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
